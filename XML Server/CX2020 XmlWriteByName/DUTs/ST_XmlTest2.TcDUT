TYPE ST_XmlTest2 :
STRUCT
	Year:INT;
	Month: ARRAY [1..12] OF BOOL;
	L_Time:LREAL;
END_STRUCT
END_TYPE
