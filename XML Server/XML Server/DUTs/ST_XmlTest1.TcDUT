TYPE ST_XmlTest1 :
STRUCT
	name:WSTRING;
	old: INT;
	sex: WSTRING;
	height: LREAL;
	weight: LREAL;
END_STRUCT
END_TYPE
